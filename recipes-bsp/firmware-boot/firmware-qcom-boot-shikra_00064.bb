require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "305391e8a63f6ca0cf6a27df301c3811697ceee1ea014d2c01d499a24252849b"
